# Keil uVision project kernel_Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: kernel_Template
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\user;.\doc;.\Freeros_Source;.\Freertos_Ports
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac5.sct
  group user
    ./user/: main.c
  group Freertos/Ports
    ./Freertos_Ports/: list.h portmacro.h task.h FreeRTOSConfig.h projdefs.h FreeRTOS.h
  group Freertos/Source
    ./Freeros_Source/: list.c task.c port.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.3
